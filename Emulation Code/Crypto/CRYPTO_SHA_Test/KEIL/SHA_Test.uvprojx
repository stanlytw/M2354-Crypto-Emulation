# Keil uVision project SHA_Test.uvprojx, settings and files
target SHA160_Test_Short (6120000::V6.12::.\ARMCLANG)
  device: M2354ES Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.17
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x30008000,0x10000) IROM(0x00000000,0x40000) IROM2(0x10040000,0x40000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: SHA_Test
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=3
  c define: DEBUG_PORT=UART0,SHA160_TEST=1
  c include: ..\..\SimpleTest;..\..\..\..\Library\Device\Nuvoton\M2354\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Include
  asm define: Stack_Size=0x1000,SHA1_TEST_SHORT=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
  group User
    ../: sha_image.s SHA_test.c sha1.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c crypto.c clk.c
  group CMSIS
    ../../../../Library/Device/Nuvoton/M2354/Source/: system_M2354.c
    ../../../../Library/Device/Nuvoton/M2354/Source/ARM/: startup_M2354.s
target SHA224_Test_Short (6120000::V6.12::.\ARMCLANG)
  device: M2354ES Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.17
  cpu: as above
  output: SHA_Test
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: as above
  c flags: OneElfS=1 v6Lang=1 v6LangP=3
  c define: DEBUG_PORT=UART0,SHA224_TEST=1
  c include: as above
  asm define: Stack_Size=0x1000,SHA224_TEST_SHORT=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
target SHA256_Test_Short (6120000::V6.12::.\ARMCLANG)
  device: M2354ES Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.17
  cpu: as above
  output: SHA_Test
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: as above
  c flags: OneElfS=1 v6Lang=1 v6LangP=3
  c define: DEBUG_PORT=UART0,SHA256_TEST=1
  c include: as above
  asm define: Stack_Size=0x1000,SHA256_TEST_SHORT=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
target SHA384_Test_Short (6120000::V6.12::.\ARMCLANG)
  device: M2354ES Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.17
  cpu: as above
  output: SHA_Test
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: as above
  c flags: OneElfS=1 v6Lang=1 v6LangP=3
  c define: DEBUG_PORT=UART0,SHA384_TEST=1
  c include: as above
  asm define: Stack_Size=0x1000,SHA384_TEST_SHORT=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
target SHA160_Test (6120000::V6.12::.\ARMCLANG)
  device: M2354ES Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.17
  cpu: as above
  output: SHA_Test
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: as above
  c flags: OneElfS=1 v6Lang=1 v6LangP=3
  c define: DEBUG_PORT=UART0,SHA160_TEST=1
  c include: as above
  asm define: Stack_Size=0x1000,SHA1_TEST=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
target SHA224_Test (6120000::V6.12::.\ARMCLANG)
  device: M2354ES Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.17
  cpu: as above
  output: SHA_Test
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: as above
  c flags: OneElfS=1 v6Lang=1 v6LangP=3
  c define: DEBUG_PORT=UART0,SHA224_TEST=1
  c include: as above
  asm define: Stack_Size=0x1000,SHA224_TEST=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
target SHA256_Test (6120000::V6.12::.\ARMCLANG)
  device: M2354ES Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.17
  cpu: as above
  output: SHA_Test
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: as above
  c flags: OneElfS=1 v6Lang=1 v6LangP=3
  c define: DEBUG_PORT=UART0,SHA256_TEST=1
  c include: as above
  asm define: Stack_Size=0x1000,SHA256_TEST=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
target SHA384_Test1 (6120000::V6.12::.\ARMCLANG)
  device: M2354ES Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.17
  cpu: as above
  output: SHA_Test
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: as above
  c flags: OneElfS=1 v6Lang=1 v6LangP=3
  c define: DEBUG_PORT=UART0,SHA384_TEST=1
  c include: as above
  asm define: Stack_Size=0x1000,SHA384_TEST1=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
target SHA384_Test2 (6120000::V6.12::.\ARMCLANG)
  device: M2354ES Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.17
  cpu: as above
  output: SHA_Test
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: as above
  c flags: OneElfS=1 v6Lang=1 v6LangP=3
  c define: DEBUG_PORT=UART0,SHA384_TEST=1
  c include: as above
  asm define: Stack_Size=0x1000,SHA384_TEST2=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
target SHA384_Test3 (6120000::V6.12::.\ARMCLANG)
  device: M2354ES Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.17
  cpu: as above
  output: SHA_Test
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: as above
  c flags: OneElfS=1 v6Lang=1 v6LangP=3
  c define: DEBUG_PORT=UART0,SHA384_TEST=1
  c include: as above
  asm define: Stack_Size=0x1000,SHA384_TEST3=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
target SHA384_Test4 (6120000::V6.12::.\ARMCLANG)
  device: M2354ES Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.17
  cpu: as above
  output: SHA_Test
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: as above
  c flags: OneElfS=1 v6Lang=1 v6LangP=3
  c define: SHA384_TEST=1
  c include: as above
  asm define: Stack_Size=0x2000  SHA384_TEST4=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
  link misc: --map --first='startup_M2354.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
target SHA512_Test1 (6120000::V6.12::.\ARMCLANG)
  device: M2354ES Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.17
  cpu: as above
  output: SHA_Test
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: as above
  c flags: OneElfS=1 v6Lang=1 v6LangP=3
  c define: SHA512_TEST=1
  c include: as above
  asm define: Stack_Size=0x2000  SHA512_TEST1=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
  link misc: as above
target SHA512_Test2 (6120000::V6.12::.\ARMCLANG)
  device: M2354ES Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.17
  cpu: as above
  output: SHA_Test
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: as above
  c flags: OneElfS=1 v6Lang=1 v6LangP=3
  c define: SHA512_TEST=1
  c include: as above
  asm define: Stack_Size=0x2000  SHA512_TEST2=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
  link misc: as above
target SHA512_Test3 (6120000::V6.12::.\ARMCLANG)
  device: M2354ES Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.17
  cpu: as above
  output: SHA_Test
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: as above
  c flags: OneElfS=1 v6Lang=1 v6LangP=3
  c define: SHA512_TEST=1
  c include: as above
  asm define: Stack_Size=0x2000  SHA512_TEST3=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
  link misc: as above
target SHA512_Test4 (6120000::V6.12::.\ARMCLANG)
  device: M2354ES Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.17
  cpu: as above
  output: SHA_Test
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: as above
  c flags: OneElfS=1 v6Lang=1 v6LangP=3
  c define: SHA512_TEST=1
  c include: as above
  asm define: Stack_Size=0x2000  SHA512_TEST4=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
  link misc: as above
